** sch_path: design/JNW_GR01_SKY130A/simv3.sch
**.subckt simv3
x1 net1 net2 0 Total_system
V1 net1 0 1.8
R1 net2 0 100 m=1
**.ends
.end
