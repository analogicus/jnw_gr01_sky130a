** sch_path: design/JNW_GR01_SKY130A/simv3.sch
**.subckt simv3
x1 net1 i_avoir 0 Total_system
V2 net1 0 1.8
R1 net2 0 1k m=1
V1 i_avoir net2 0
**.ends
.end
